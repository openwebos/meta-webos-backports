FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-dbus-Register-the-AutoScan-method-call-at-the-right-.patch"
