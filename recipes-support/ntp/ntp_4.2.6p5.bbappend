# LICENSE is case sensitive and ntp.inc in meta-oe has "ntp"
# See http://git.openembedded.org/meta-openembedded/commit/meta-networking/recipes-support/ntp?id=c9a18a88456bd459b34de4e9a7f4f8c0b9d669b1

LICENSE = "NTP"
