# Copyright (c) 2013 LG Electronics, Inc.

BBCLASSEXTEND = "native"
